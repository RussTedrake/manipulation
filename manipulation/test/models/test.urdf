Commit message: fix handling of file://

File: manipulation/test/models/test.urdf (robot description, URDF)
Before this commit: robot test, 1 links, 0 joints
Links:
- link body: geometry visual mesh filename=cube.dae; visual mesh filename=cube.obj
